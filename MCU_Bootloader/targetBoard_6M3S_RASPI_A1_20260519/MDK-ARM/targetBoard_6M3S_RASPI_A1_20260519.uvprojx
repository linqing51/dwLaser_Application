# Keil uVision project targetBoard_6M3S_RASPI_A1_20260519.uvprojx, settings and files
target targetBoard_6M3S_RASPI_A1_20260519 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: dwLaser_Bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,CORE_6M3S_JL_FC_1940_1470_635,MCU_BOOTLOADER
  c include: ../FATFS/Target;../FATFS/App;../USB_HOST/App;../USB_HOST/Target;../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src;../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;../../../MCU_Application/config;../../../MCU_Application/lib;../../../MCU_Application/sPlc;../../../MCU_Application/sPlcPort;../../../MCU_Application/MainApp;../../Bootloader;../../../MCU_Application/sPlcPort/CORE_6M3S_JL_FC_1470_1940
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c crc.c dac.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: usbh_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/USB_HOST/App
    ../USB_HOST/App/: usb_host.c
  group Application/User/USB_HOST/Target
    ../USB_HOST/Target/: usbh_conf.c usbh_platform.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Bootloader
    ../../Bootloader/: bootLoader.c
    ../../../MCU_Application/lib/: libdbg.c flash_if.c libcrc.c
    ../../../MCU_Application/sPlcPort/: sPlcEprom.c sPlcEprom_SPI.c
software components: CMSIS:CORE 4.3.0
