# Keil uVision project targetBoard_G5_TRI_A1_20260915.uvprojx, settings and files
target targetBoard_G5_TRI_A1_20260915 (5060960::V5.06 update 7 (build 960)::.\BIN)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: MCU_Application +hex
  AfterMake: D:\GitHub\dwLaser_Application\MCU_Application\targetBoard_G5_TRI_A1\MDK-ARM\convert.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,ARM_MATH_CM4,USER_VECT_TAB_ADDRESS,LDR2P1_G5_A1_20250731_TRIP,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,STM32F405xx
  c include: ../FATFS/Target;../FATFS/App;../USB_HOST/App;../USB_HOST/Target;../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src;../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Inc;../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../sPlc;../../sPlcPort;../../lib;../../MainApp;../../deviceInfo;../../dcHmi;../Middlewares/Third_Party/ARM_CMSIS/CMSIS/Core/Include/;../Middlewares/Third_Party/ARM_CMSIS/CMSIS/Core_A/Include/;../Middlewares/Third_Party/ARM_CMSIS/CMSIS/DSP/Include;../Middlewares/ST/STM32_USB_Host_Library/Class/AUDIO/Inc;../Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Inc;../Middlewares/ST/STM32_USB_Host_Library/Class/MTP/Inc;../LIBJPEG/App;../LIBJPEG/Target;../MBEDTLS/App;../Middlewares/Third_Party/LibJPEG/include;../Middlewares/Third_Party/mbedTLS/include/mbedtls;../Middlewares/Third_Party/mbedTLS/include
  asm include: ../Drivers/CMSIS/Include;../Middlewares/Third_Party/ARM_CMSIS/CMSIS/Core_A/Include/;../Middlewares/Third_Party/ARM_CMSIS/CMSIS/DSP/Include
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c crc.c dac.c dma.c rng.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: usbh_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/USB_HOST/App
    ../USB_HOST/App/: usb_host.c
  group Application/User/USB_HOST/Target
    ../USB_HOST/Target/: usbh_conf.c usbh_platform.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/AUDIO/Src/: usbh_audio.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Src/: usbh_cdc.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MTP/Src/: usbh_mtp.c usbh_mtp_ptp.c
  group lib
    ../../lib/: flash_if.c libcpu.c libcrc.c libdbg.c pid_temp_control.c fuzzy_pid.c fan_controller.c
  group sPlc
    ../../sPlc/: sPlc.c sPlcFun.c
  group sPlcPort
    ../../sPlcPort/: sPlcAdc.c sPlcDac.c sPlcEprom.c sPlcIoIn.c sPlcIoOut.c sPlcLaser.c sPlcMisc.c sPlcSpeaker.c sPlcTimer.c sPlcPMU_LTC2955.c sPlcPMU_STM32.c sPlcI2C_HDC1080.c sPlcEprom_SPI.c sPlcEprom_I2C.c sPlcRtc.c
  group dcHmi
    ../../dcHmi/: hmiCmdQueue.c hmiDriver.c hmiUserUart.c
  group MainApp
    ../../MainApp/: MainApp.c dcHmiApp.c dcHmiLanguage.c dcHmiNotifyButton.c dcHmiNotifyProgress.c dcHmiNotifyReadRTC.c dcHmiNotifyText.c MainAppLib.c preSchemeDual_1470.c preSchemeDual_1940.c preSchemeTrip.c statusLoop.c tempCtrLoop.c wfswLoop.c
  group Middlewares/CMSIS/CMSIS/DSP/Library
    ../Middlewares/Third_Party/ARM_CMSIS/CMSIS/DSP/Lib/ARM/: arm_cortexM4lf_math.lib
  group Application/User/LIBJPEG/App
    ../LIBJPEG/App/: libjpeg.c
  group Application/User/LIBJPEG/Target
    ../LIBJPEG/Target/: jdata_conf.c
  group Application/User/MBEDTLS/Target
    ../MBEDTLS/Target/: hardware_rng.c
  group Application/User/MBEDTLS/App
    ../MBEDTLS/App/: mbedtls.c
  group Middlewares/LibJPEG
    ../Middlewares/Third_Party/LibJPEG/source/: jcapimin.c jcapistd.c jdapimin.c jdapistd.c jcomapi.c jcparam.c jctrans.c jdtrans.c jcinit.c jcmaster.c jcmainct.c jcprepct.c jccoefct.c jccolor.c jcsample.c jcdctmgr.c jfdctint.c jfdctfst.c jfdctflt.c jchuff.c jcarith.c jcmarker.c jdatadst.c jdmaster.c jdinput.c jdmainct.c jdcoefct.c jdpostct.c jdmarker.c jdhuff.c jdarith.c jddctmgr.c jidctint.c jidctfst.c jidctflt.c jdsample.c jdcolor.c jdmerge.c jquant1.c jquant2.c jdatasrc.c jaricom.c jerror.c jmemmgr.c jutils.c jmemnobs.c
  group Middlewares/mbedTLS
    ../Middlewares/Third_Party/mbedTLS/library/: aes.c asn1parse.c asn1write.c base64.c bignum.c camellia.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c ctr_drbg.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c entropy_poll.c gcm.c hkdf.c md.c md_wrap.c memory_buffer_alloc.c oid.c pem.c pk.c pkparse.c pk_wrap.c platform.c platform_util.c poly1305.c rsa_internal.c sha256.c sha512.c ssl_ciphersuites.c version_features.c x509.c x509_crt.c
    ../Middlewares/Third_Party/mbedTLS/include/: CMakeLists.txt
software components: CMSIS:CORE 6.2.0
